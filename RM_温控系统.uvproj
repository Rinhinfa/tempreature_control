# Keil uVision project RM_温控系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: RM_温控系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Wire_DQ.c Wire_DQ.h Delay.c Delay.h LCD1602.c LCD1602.h DS18B20.c DS18B20.h tb6612.c timer.c timer.h tb6612.h
